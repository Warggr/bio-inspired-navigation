Commit message: aesthetics

File: system/controller/simulation/p3dx/urdf/pioneer3dx.urdf (robot description, URDF)
Before this commit: robot pioneer3dx, 10 links, 9 joints
Joints:
- joint center_wheel_joint: axis (none) -> 0 1 0
